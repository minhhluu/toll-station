# Keil uVision project Bai_3.uvproj, settings and files
target Target 1 (MCS-51)
  device: AT89C52 Microchip
  cpu: IRAM(0-0xFF) IROM(0-0x1FFF) CLOCK(24000000)
  output: Bai_3 +hex
  c flags: Optimize=8 SizeSpeed=1
  link misc: ru
  group Source Group 1
    ./: STARTUP.A51 main.c
    ./00_Library/: UART_Mode_1.c Delay.c LCD_1602.c
